# IAR project mbOS_kernel.ewp, settings and files
configuration CM0 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: mbOS_kernel.out
configuration CM3 (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
configuration ARM16 (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
configuration ARM32 (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
configuration CM4F (ARM)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
  group Core
    ../../../Source/: dataqueue.c delay.c event.c kernel.c mempool.c msgqueue.c mutex.c scheduler.c semaphore.c system.c systick.c thread.c timer.c
  group Handlers
    ../../../Source/IAR/: irq_arm.s irq_cm0.s irq_cm3.s irq_cm4f.s
