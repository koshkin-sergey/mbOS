# Keil uVision project mbOS_kernel.uvproj, settings and files
target ARM_16 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: Kernel_ARM16 (library)
  AfterMake: cmd.exe /C copy ARMv4T\Kernel_ARM16.lib ..\.
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\Include
  group Core
    ../../../Source/: dataqueue.c delay.c event.c kernel.c mempool.c msgqueue.c mutex.c semaphore.c system.c systick.c thread.c timer.c
  group Handlers
    ../../../Source/ARM/: irq_arm.s irq_cm0.s irq_cm3.s irq_cm4f.s
target ARM_32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: Kernel_ARM32 (library)
  AfterMake: cmd.exe /C copy ARMv4T\Kernel_ARM32.lib ..\.
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\Include
target Cortex_M0 (6150000::V6.15::ARMCLANG)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Kernel_CM0 (library)
  AfterMake: cmd.exe /C copy Cortex_M0\Kernel_CM0.lib ..\.
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Include
target Cortex_M3 (6150000::V6.15::ARMCLANG)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: Kernel_CM3 (library)
  AfterMake: cmd.exe /C copy Cortex_M3\Kernel_CM3.lib ..\.
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Include
target Cortex_M4F (6150000::V6.15::ARMCLANG)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Kernel_CM4F (library)
  AfterMake: cmd.exe /C copy Cortex_M4F\Kernel_CM4F.lib ..\.
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Include
