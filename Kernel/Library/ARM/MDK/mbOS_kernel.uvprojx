# Keil uVision project mbOS_kernel.uvprojx, settings and files
target Cortex_M0 (6120000::V6.12::.\ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Kernel_CM0 (library)
  AfterMake: cmd.exe /C copy Cortex_M0\Kernel_CM0.lib ..\.
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\Include;..\..\..\..\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    ../../../Source/: dataqueue.c delay.c event.c kernel.c mempool.c msgqueue.c mutex.c semaphore.c thread.c timer.c
  group Handlers
    ../../../Source/ARM/: irq_cm0.s irq_cm3.s
target Cortex_M3 (6120000::V6.12::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Kernel_CM3 (library)
  AfterMake: cmd.exe /C copy Cortex_M3\Kernel_CM3.lib ..\.
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\Include;..\..\..\..\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Cortex_M4 (6120000::V6.12::.\ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: Kernel_CM4 (library)
  AfterMake: cmd.exe /C copy Cortex_M4\Kernel_CM4.lib ..\.
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\Include;..\..\..\..\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
