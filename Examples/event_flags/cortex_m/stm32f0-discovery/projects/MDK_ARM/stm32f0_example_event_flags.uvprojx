# Keil uVision project stm32f0_example_event_flags.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f0_example_event_flags
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F051
  c include: ..\..\src\include;..\..\..\..\..\..\src\include;..\..\..\..\..\..\src\CMSIS\Core\Include;..\..\..\..\..\..\src\Config
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ../../src/: stm32f0_example_event_flags.c
    ../../src/Device/: system_stm32f0xx.c
    ../../src/Device/arm/: startup_stm32f051x8.s
  group RTOS
    ../../../../../../src/kernel/: dataqueue.c delay.c event.c kernel.c mempool.c message_que.c mutex.c os_lib.c semaphore.c thread.c timer.c
    ../../../../../../src/kernel/ARM/: irq_cm0.s
    ../../../../../../src/Config/: RTOS_Config.c
