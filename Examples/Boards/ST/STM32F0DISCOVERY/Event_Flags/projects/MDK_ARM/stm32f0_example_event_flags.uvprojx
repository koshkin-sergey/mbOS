# Keil uVision project stm32f0_example_event_flags.uvprojx, settings and files
target Debug (6150000::V6.15::ARMCLANG)
  device: STM32F051R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f0_example_event_flags
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\..\..\..\Include;..\..\..\..\..\..\..\Device\STMicroelectronics\STM32F0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\ARMCM0_ac6.sct
  group src
    ../../: stm32f0_example_event_flags.c
    ../../../../../../../Device/STMicroelectronics/STM32F0xx/Startup/: startup_stm32f051x8.c system_stm32f0xx.c
  group rtos
    ../../../Common/Config/: kernel_lib.c
    ../../../../../../../Kernel/Library/ARM/: Kernel_CM0.lib
  group driver
    ../../../../../../../Device/STMicroelectronics/STM32F0xx/Driver/: GPIO_STM32F0xx.c RCC_STM32F0xx.c
