# IAR project stm32f0_example_event_flags.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051R8 ST STM32F051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F051x8
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Include; ..\..\..\..\..\..\..\Device\STMicroelectronics\STM32F0xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: stm32f0_example_event_flags.out
  ILINK.IlinkIcfFile: stm32f051x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  group src
    ../../: stm32f0_example_event_flags.c
  group src/Config
    ../../../../../../../Kernel/Library/IAR/: Kernel_CM0.a
    ../../../Common/Config/: kernel_lib.c
  group src/Device/Drivers
    ../../../../../../../Device/STMicroelectronics/STM32F0xx/Driver/: GPIO_STM32F0xx.c RCC_STM32F0xx.c
  group src/Device/Startup
    ../../../../../../../Device/STMicroelectronics/STM32F0xx/Startup/: startup_stm32f051x8.c system_stm32f0xx.c
