# Keil uVision project stm32f4_example_timers.uvprojx, settings and files
target Debug (6120000::V6.12::.\ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4_example_timers
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F407xx
  c include: ..\..\..\..\..\..\..\Include;..\..\..\..\..\..\..\Device\STMicroelectronics\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f4xx_ac6.sct
  group src
    ../../../../../../../Device/STMicroelectronics/STM32F4xx/Startup/: startup_stm32f407xx.c system_stm32f4xx.c
    ../../: stm32f4_example_timers.c
  group rtos
    ../../../Common/Config/: kernel_config.c kernel_lib.c
    $TC_ROOT$/../../Projects/mbOS/Kernel/Library/ARM/: Kernel_CM4.lib
  group driver
    ../../../../../../../Device/STMicroelectronics/STM32F4xx/Driver/: GPIO_STM32F4xx.c RCC_STM32F4xx.c
