<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm32f4_example_timers.ewp</path>
    </project>
    <batchBuild />
</workspace>
