# IAR project stm32f4_example_timers.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F407xx
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Include; ..\..\..\..\..\..\..\Device\STMicroelectronics\STM32F4xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f4_example_timers.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group RTOS
    ../../../../../../../Kernel/Library/IAR/: Kernel_CM4.a
    ../../../Common/Config/: kernel_config.c kernel_lib.c
  group src
    ../../: stm32f4_example_timers.c
  group src/Device
    ../../../../../../../Device/STMicroelectronics/STM32F4xx/Startup/: startup_stm32f407xx.c system_stm32f4xx.c
  group src/driver
    ../../../../../../../Device/STMicroelectronics/STM32F4xx/Driver/: GPIO_STM32F4xx.c RCC_STM32F4xx.c
