# Keil uVision project ADUCM32x_I2C_Master.uvproj, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ADuC7023 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768000) CPUTYPE(ARM7TDMI)
  output: ADUCM32x_I2C_Master
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\..\..\..\Include;..\..\..\..\..\..\..\Device\ADI\ADuC7023\Include
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  scatter file: .\aduc7023_ac5.sct
  group src
    ../../src/: main.c
  group Device
    ../../../../../../../Device/ADI/ADuC7023/Startup/: system_aduc7023.c
    ../../../../../../../Device/ADI/ADuC7023/Startup/arm/: startup_aduc7023.c
    ../../../../../../../Device/ADI/ADuC7023/Driver/: GPIO_ADUC7023.c PCC_ADUC7023.c IRQ_ADUC7023.c RTOS_TIMER_ADUC7023.c
    ../../../../../../../Device/ADI/ADuC7023/CMSIS/Driver/: I2C_ADUC7023.c
  group Kernel
    ../../../../../../../Kernel/Library/ARM/: Kernel_ARM16.lib
    ../../../Common/Config/: kernel_lib.c
