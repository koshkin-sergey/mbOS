# IAR project ADUC7023_I2C_Master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuC7023 AnalogDevices ADuC7023
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Include; ..\..\..\..\..\..\..\Device\ADI\ADuC7023\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADUC7023_I2C_Master.srec
  ILINK.IlinkOutputFile: ADUC7023_I2C_Master.out
  ILINK.IlinkIcfFile: aduc7023.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Device
    ../../../../../../../Device/ADI/ADuC7023/Driver/: GPIO_ADUC7023.c IRQ_ADUC7023.c PCC_ADUC7023.c RTOS_TIMER_ADUC7023.c
    ../../../../../../../Device/ADI/ADuC7023/CMSIS/Driver/: I2C_ADUC7023.c
    ../../../../../../../Device/ADI/ADuC7023/Startup/iar/: startup_aduc7023.c
    ../../../../../../../Device/ADI/ADuC7023/Startup/: system_aduc7023.c
  group Kernel
    ../../../../../../../Kernel/Library/IAR/: Kernel_ARM16.a
    ../../../Common/Config/: kernel_lib.c
  group src
    ../../src/: main.c
