# IAR project aduc7023_switch_time.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuC7023 AnalogDevices ADuC7023
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Include; ..\..\..\..\..\..\..\Device\ADI\ADuC7023\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: aduc7023_timer_example.srec
  ILINK.IlinkOutputFile: aduc7023_timer_example.out
  ILINK.IlinkIcfFile: aduc7023.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  group Device
    ../../../../../../../Device/ADI/ADuC7023/Driver/: GPIO_ADUC7023.c IRQ_ADUC7023.c PCC_ADUC7023.c RTOS_TIMER_ADUC7023.c
    ../../../../../../../Device/ADI/ADuC7023/Startup/iar/: startup_aduc7023.c
    ../../../../../../../Device/ADI/ADuC7023/Startup/: system_aduc7023.c
  group Kernel
    ../../../../../../../Kernel/Library/IAR/: Kernel_ARM16.a
    ../../../Common/Config/: kernel_lib.c
  group src
    ../../: main.c
