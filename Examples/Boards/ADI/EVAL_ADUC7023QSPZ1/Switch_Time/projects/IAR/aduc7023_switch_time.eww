<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\aduc7023_switch_time.ewp</path>
    </project>
    <batchBuild />
</workspace>
