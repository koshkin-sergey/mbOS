<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADUCM32x_I2C_Slave.ewp</path>
    </project>
    <batchBuild />
</workspace>
