# IAR project ADUCM32x_I2C_Master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM320 AnalogDevices ADuCM320
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ADUCM320I
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Include; ..\..\..\..\..\..\..\Device\ADI\ADuCM32x\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADUCM32x_I2C_Master.srec
  ILINK.IlinkOutputFile: ADUCM32x_I2C_Master.out
  ILINK.IlinkIcfFile: aducm32x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Device
    ../../../../../../../Device/ADI/ADuCM32x/Driver/: CLK_ADUCM32x.c GPIO_ADUCM32x.c WDT_ADUCM32x.c
    ../../../../../../../Device/ADI/ADuCM32x/CMSIS/Driver/: I2C_ADUCM32x.c
    ../../../../../../../Device/ADI/ADuCM32x/Startup/: startup_aducm32x.c system_aducm32x.c
  group Kernel
    ../../../../../../../Kernel/Library/IAR/: Kernel_CM3.a
    ../../../Common/Config/: kernel_lib.c
  group src
    ../../src/: main.c
