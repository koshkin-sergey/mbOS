# Keil uVision project ADUCM32x_I2C_Master.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: ADuCM320i Analog Devices
  pack: AnalogDevices.ADuCM320_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADUCM32x_I2C_Master
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ADUCM320I
  c include: ..\..\..\..\..\..\..\Include;..\..\..\..\..\..\..\Device\ADI\ADuCM32x\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\aducm32x_ac6.sct
  group src
    ../../src/: main.c
  group Device
    ../../../../../../../Device/ADI/ADuCM32x/Startup/: startup_aducm32x.c system_aducm32x.c
    ../../../../../../../Device/ADI/ADuCM32x/Driver/: GPIO_ADUCM32x.c CLK_ADUCM32x.c WDT_ADUCM32x.c
    ../../../../../../../Device/ADI/ADuCM32x/CMSIS/Driver/: I2C_ADUCM32x.c
  group Kernel
    ../../../Common/Config/: kernel_lib.c
    ../../../../../../../Kernel/Library/ARM/: Kernel_CM3.lib
