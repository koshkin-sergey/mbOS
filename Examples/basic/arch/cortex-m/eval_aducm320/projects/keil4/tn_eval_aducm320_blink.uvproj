# Keil uVision project tn_eval_aducm320_blink.uvproj, settings and files
target ADuCM320 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ADuCM320 Analog Devices
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x0000000-0x003FFFF) CLOCK(80000000) CPUTYPE("Cortex-M3")
  output: tn_eval_aducm320_blink
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\src\include;..\..\..\..\..\..\..\src\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group init
    ../../src/init/: startup_ADuCM320.s system_ADuCM320.c
  group src
    ../../src/: tn_eval_aducm320_example_blink.c
  group tnkernel
    ../../../../../../../src/kernel/: tn.c tn_delay.c tn_dqueue.c tn_event.c tn_mem.c tn_message_buf.c tn_mutex.c tn_sem.c tn_sprintf.c tn_tasks.c tn_timer.c tn_utils.c
    ../../../../../../../src/arch/cortex_m3/: tn_port_cm3.c tn_port_cm3_armcc.s
