# Keil uVision project stm32f0_example_basic.uvprojx, settings and files
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f0_example_basic
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\..\..\src\include;..\..\src\include;..\..\..\..\..\..\..\src\arch\cortex_m
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group uKernel
    ../../../../../../../src/arch/cortex_m/: hal_cm.c
    ../../../../../../../src/kernel/: delay.c event.c mem.c mutex.c que.c semaphore.c system.c task.c timer.c data_que.c message_que.c
  group src
    ../../src/init/: system_stm32f0xx.c startup_stm32f051.s
    ../../src/: stm32f0_example_basic.c
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: as above
  output: stm32f0_example_basic
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
